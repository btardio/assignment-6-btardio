## base_external/package/Config.in
```kconfig
menu "AESD Packages"
    source "package/aesd-assignments/Config.in"
endmenu
menu "My OpenSSL"
    source "package/myopenssl/Config.in"
endmenu
```
