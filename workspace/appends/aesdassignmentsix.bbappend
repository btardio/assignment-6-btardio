inherit externalsrc
EXTERNALSRC = "/repo/server"
EXTERNALSRC_BUILD = "/repo/server"
